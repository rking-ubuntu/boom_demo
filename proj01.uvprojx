# Keil uVision project proj01.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: proj01 +hex
  c flags: Optim=1
  c include: ..\按键+数码管+呼吸灯+adc_v5
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: startup_LPC11xx.s blinky.c beep.c digitSeg.c key.c led.c system_init.c timer.c adc.c
